# Keil uVision project Project.uvprojx, settings and files
target 2026570827 (6240000::V6.24::ARMCLANG)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: ./keil5_disp_size_bar.exe
  AfterMake: fromelf --bin --output=.\output\App.bin .\output\Project.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F470,__PERF_COUNTER_CFG_USE_SYSTICK_WRAPPER__
  c include: ..\Library\Include;..\CMSIS\Driver\CMSIS_6\Include;..\CMSIS\Driver;..\HeaderFiles;..\HeaderFiles\common;..\HeaderFiles\user;..\Driver\bsp;..\Driver\oled;..\Driver\gd25qxx;..\Driver\gd30ad3344;..\Function;..\Protocol\ota_uart;..\Protocol;..\Library\Third_Party\perf_counter-2.5.4;..\System;..\startup
  library: MicroLIB
  memory RVCT4: ROM 0x8011000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\App_F470.sct
  group System
    ../System/src/: gd32f4xx_it.c main.c
    ../System/: systick.c
  group Common
    ../HeaderFiles/common/: bl_partition.h bl_param.h ota_protocol.h
  group OTA_APP
    ../Protocol/ota_uart/: ota_uart.c ring_buffer.c
  group Protocol
    ../Protocol/: crc16_modbus.c frame_builder.c frame_parser.c cmd_handler.c
  group Driver/bsp
    ../Driver/bsp/: cimc_f470vet6.c cimc_f470vet6.h
  group Driver/gd25qxx
    ../Driver/gd25qxx/: gd25qxx.c
  group Driver/oled
    ../Driver/oled/: oled.c
  group Driver/gd30ad3344
    ../Driver/gd30ad3344/: gd30ad3344.c
  group APP
    ../Function/: led_app.c oled_app.c scheduler.c usart_app.c rtc_app.c adc_app.c dac_app.c pt100_app.c param_store.c alarm_app.c key_app.c
  group Peripherals
    ../Library/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../startup/: startup_gd32f450_470.s
  group CMSIS
    ../System/: system_gd32f4xx.c
  group Utilities
    ../Library/Third_Party/perf_counter-2.5.4/: perf_counter.c perfc_port_default.c systick_wrapper_ual.s
